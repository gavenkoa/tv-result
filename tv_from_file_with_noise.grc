options:
  parameters:
    author: user
    generate_options: qt_gui
    id: tv_from_file
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: noise1_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '2'
    value: '0'
  states: {}
- name: noise1_freq
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: 3e6
    value: '1000'
  states: {}
- name: noise2_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '2'
    value: '0'
  states: {}
- name: noise2_high_freq
  id: variable_qtgui_range
  parameters:
    start: 10e3
    step: 10e3
    stop: 3e6
    value: 1e6
  states: {}
- name: noise2_low_freq
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: 10e3
    stop: 3e6
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 9.7e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: noise1_amp
    freq: noise1_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: noise2_amp
    high_cutoff_freq: noise2_high_freq
    low_cutoff_freq: noise2_low_freq
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 200e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: filerepeater_file_repeater_ex_0
  id: filerepeater_file_repeater_ex
  parameters:
    complexconv: '0'
    delayFirstStart: '0.0'
    file: C:\Users\user\work\achilles\tv\ua-10s.cfile
    repeat: 'True'
    repeat_delay: '0'
    repeat_times: '0'
    type: complex
    verbose: 'False'
    vlen: '1'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: 591.25e6
    gain0: '0'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', band_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [filerepeater_file_repeater_ex_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
